options:
  parameters:
    author: Carlos_Jonathan
    copyright: UIS
    generate_options: qt_gui
    id: Moduladoramplitudcajo
    output_language: python
    title: Modulador_AM_GNUradio
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud potadora
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0.25'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.01'
    stop: '2'
    value: '1'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: Fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia del mensaje
    start: '0'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente de sensibilidad AM
    start: '-4'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12.5e6/64
  states: {}
- name: CalculoPotenciaComunicaciones_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: Fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: lab_3_0
  id: lab_3
  parameters:
    ac: Ac
    ka: Ka
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    name: '"envolvente compleja"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Envolvente compleja"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', lab_3_0, '0']
- [blocks_complex_to_real_0, '0', CalculoPotenciaComunicaciones_0, '0']
- [lab_3_0, '0', blocks_complex_to_real_0, '0']
- [lab_3_0, '0', qtgui_freq_sink_x_0, '0']
- [lab_3_0, '0', qtgui_time_sink_x_0, '0']
- [lab_3_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
