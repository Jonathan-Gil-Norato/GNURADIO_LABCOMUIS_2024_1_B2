options:
  parameters:
    author: Carlos_Jonathan
    copyright: UIS
    generate_options: qt_gui
    id: Moduladoramplitudcajo
    output_language: python
    title: Modulador_AM_GNUradio
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud de la modulante
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud potadora
    start: '0'
    step: '100e-6'
    stop: '1'
    value: '0.1'
  states: {}
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia del transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: Ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente de sensibilidad
    start: '0'
    step: '100e-6'
    stop: '4'
    value: '1'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje
    start: 1e3
    step: 1e3
    stop: 300e3
    value: 200e3
  states: {}
- name: CalculoPotenciaComunicaciones_0_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: CalculoPotenciaComunicaciones_0_0_0
  id: CalculoPotenciaComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Downloads/despecha_rosalia.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Downloads/rebelion_joearroyo (1).wav
    repeat: 'True'
  states: {}
- name: lab4parteb_0
  id: lab4parteb
  parameters:
    Ac: Ka
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: '200000'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: '200000'
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    clock_source0: external
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    clock_rate: 120e6
    gain0: '0'
    samp_rate: 500e6
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0_0, '0', audio_sink_0, '1']
- [blocks_wavfile_source_0_0, '0', audio_sink_0_0, '0']
- [blocks_wavfile_source_0_0, '0', rational_resampler_xxx_0_0, '0']
- [lab4parteb_0, '0', qtgui_freq_sink_x_0, '0']
- [lab4parteb_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0, '0', CalculoPotenciaComunicaciones_0_0_0, '0']
- [rational_resampler_xxx_0, '0', lab4parteb_0, '0']
- [rational_resampler_xxx_0_0, '0', CalculoPotenciaComunicaciones_0_0, '0']
- [rational_resampler_xxx_0_0, '0', lab4parteb_0, '1']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
