options:
  parameters:
    author: Carlos_Jonathan
    category: '[Modulador Car_Jon]'
    copyright: UIS
    description: Envolvente compleja para modulador AM
    generate_options: hb
    id: lab_3
    output_language: python
    title: Modulator AM jojo
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ac
  id: parameter
  parameters:
    label: Amplitud portadora
    type: complex
    value: '1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ka
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ac
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: ka
  id: parameter
  parameters:
    label: Coeficienta ka
    type: eng_float
    value: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: s(t)
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: m(t)
    type: float
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', pad_sink_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
